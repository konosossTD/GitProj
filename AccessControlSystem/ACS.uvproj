# Keil uVision project ACS.uvproj, settings and files
target AccessControlSystem (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ACS +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Modules
    ./: 1602.c beep.c delay.c func.c IIC.c uart.c user.c key.c ds1302.c BioSensor.c timer0.c eeprom.c servo.c int0.c
